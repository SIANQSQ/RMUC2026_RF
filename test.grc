options:
  parameters:
    author: qsq
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '9'
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0,0,0,1,0,1,0,1,1)
  states: {state: disabled}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.05'
    log: 'True'
    mu: '0.5'
    omega_relative_limit: '0.02'
    samples_per_symbol: '52'
    sensitivity: '2.83227'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    do_unpack: 'False'
    log: 'True'
    samples_per_symbol: '52'
    sensitivity: '2.83227'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    Interface_KEY: '123456'
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import os

      class ota_frame_generator(gr.sync_block):
          """
          自定义空口帧生成块
          生成固定结构：[8字节Access Code][4字节双份Header][15字节Payload]
          """
          def __init__(self, Interface_KEY = "123456"):
              self.log("Start Here")
              """
              参数:
                  access_code_choice: 选择Access Code类型，"信息波"或"干扰波"
                  payload_data: 15字节的Payload数据（bytes类型），默认全0x00
              """
              gr.sync_block.__init__(
                  self,
                  name="Interference wave Generator",  
                  in_sig=None,  
                  out_sig=[np.uint8]  
              )

              # Access Code
              # 干扰波 Access Code: 0x16E8D377151C712D（大端序）
              self.access_code_jam = bytes([
                  0x16, 0xE8, 0xD3, 0x77,
                  0x15, 0x1C, 0x71, 0x2D
              ])

              # Header 
              # 固定 0x00 0x0F 0x00 0x0F
              self.header = bytes([0x00, 0x0F, 0x00, 0x0F])

              # # Payload
              # if payload_data is None:
              #     # 默认Payload：15字节全0x00（干扰数据）
              #     self.payload = bytes([0x00] * 15)
              # else:
              #     # 确保Payload是15字节
              #     if len(payload_data) != 15:
              #         raise ValueError("Payload必须是15字节！")
              #     self.payload = payload_data

              # -------------------------- 4. 组装完整帧 --------------------------
              # self.frame = self.access_code + self.header + self.payload
              # self.frame_len = len(self.frame)  # 固定27字节

              # # 用于循环输出的索引
              # self.current_idx = 0

          def generate_9byte_random_data(self):
              random_fill = os.urandom(9)
              return random_fill
          
          def log(self,str):
              print("[Python Block Debug]:"+str)
              
          def work(self, input_items, output_items):
              out = output_items[0]
              out_len = len(out)

              # 循环将帧数据填充到输出缓冲区
              bytes_written = 0
              print(self.generate_9byte_random_data)
              # while bytes_written < out_len:
              #     # 计算本次可写入的字节数
              #     remaining_in_frame = self.frame_len - self.current_idx
              #     remaining_in_out = out_len - bytes_written
              #     write_len = min(remaining_in_frame, remaining_in_out)

              #     # 复制数据到输出
              #     out[bytes_written:bytes_written+write_len] = np.frombuffer(
              #         self.frame[self.current_idx:self.current_idx+write_len],
              #         dtype=np.uint8
              #     )

              #     # 更新索引
              #     self.current_idx += write_len
              #     bytes_written += write_len

              #     # 如果一帧写完，重置索引，循环发送
              #     if self.current_idx >= self.frame_len:
              #         self.current_idx = 0

              # return bytes_written
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import serial
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, port='/dev/ttyUSB0', baudrate=9600):
              gr.sync_block.__init__(self, name='REFEREE Output', in_sig=[], out_sig=[np.uint8])
              self.ser = serial.Serial(port, baudrate, timeout=1)

          def work(self, input_items, output_items):
              if self.ser.in_waiting > 0:
                  data = self.ser.read(self.ser.in_waiting)
                  data_array = np.frombuffer(data, dtype=np.uint8)
                  n_items = min(len(data_array), len(output_items[0]))
                  output_items[0][:n_items] = data_array[:n_items]
                  return n_items
              return 0
    baudrate: '921600'
    port: '''/dev/ttyUSB0'''
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '-60.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"jietiao"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"y"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"send"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"rec"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"UART rec"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_pack_k_bits_bb_1, '0', blocks_uchar_to_float_0_1, '0']
- [blocks_repack_bits_bb_1, '0', blocks_uchar_to_float_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_gfsk_mod_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_delay_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_uchar_to_float_0_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_0_0_1_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_gfsk_demod_0, '0', blocks_pack_k_bits_bb_1, '0']
- [digital_gfsk_demod_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_gfsk_demod_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_gfsk_mod_0, '0', digital_gfsk_demod_0, '0']
- [digital_gfsk_mod_0, '0', iio_pluto_sink_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [epy_block_0, '0', blocks_uchar_to_float_1, '0']
- [epy_block_1, '0', blocks_stream_to_tagged_stream_0, '0']
- [iio_pluto_source_0, '0', digital_gfsk_demod_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0_0_1_0, '0']

metadata:
  file_format: 1
