options:
  parameters:
    author: qsq
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '9'
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0,0,0,1,0,1,0,1,1)
  states: {state: disabled}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.05'
    log: 'True'
    mu: '0.5'
    omega_relative_limit: '0.02'
    samples_per_symbol: '52'
    sensitivity: '2.83227'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    do_unpack: 'False'
    log: 'True'
    samples_per_symbol: '52'
    sensitivity: '2.83227'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import serial
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, port='/dev/ttyUSB0', baudrate=9600):
              gr.sync_block.__init__(self, name='REFEREE Output', in_sig=[], out_sig=[np.uint8])
              self.ser = serial.Serial(port, baudrate, timeout=1)

          def work(self, input_items, output_items):
              if self.ser.in_waiting > 0:
                  data = self.ser.read(self.ser.in_waiting)
                  data_array = np.frombuffer(data, dtype=np.uint8)
                  n_items = min(len(data_array), len(output_items[0]))
                  output_items[0][:n_items] = data_array[:n_items]
                  return n_items
              return 0
    baudrate: '921600'
    port: '''/dev/ttyUSB0'''
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '-60.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"jietiao"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"y"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"send"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"rec"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"UART rec"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_pack_k_bits_bb_1, '0', blocks_uchar_to_float_0_1, '0']
- [blocks_repack_bits_bb_1, '0', blocks_uchar_to_float_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_gfsk_mod_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_delay_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_uchar_to_float_0_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_0_0_1_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_gfsk_demod_0, '0', blocks_pack_k_bits_bb_1, '0']
- [digital_gfsk_demod_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_gfsk_demod_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_gfsk_mod_0, '0', digital_gfsk_demod_0, '0']
- [digital_gfsk_mod_0, '0', iio_pluto_sink_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [epy_block_1, '0', blocks_stream_to_tagged_stream_0, '0']
- [epy_block_1, '0', blocks_uchar_to_float_1, '0']
- [iio_pluto_source_0, '0', digital_gfsk_demod_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0_0_1_0, '0']

metadata:
  file_format: 1
